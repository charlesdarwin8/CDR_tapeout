<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Apr 15 15:00:18 2025</timestamp>
			<uuid>{767ca34f-4fee-4db3-80ef-126a080aa9cd}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/w/home.24/home/vineelchandra99/tsmc180test/vineel_wk/209as_tb_top_level_loop_locking_verilogA/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/w/home.24/home/vineelchandra99/tsmc180test/vineel_wk/209as_tb_top_level_loop_locking_verilogA/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/w/home.24/home/vineelchandra99/simulation/vineel_wk/209as_tb_top_level_loop_locking_verilogA/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/vineel_wk/209as_tb_top_level_loop_locking_verilogA/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
	</history>
</setupdb>
